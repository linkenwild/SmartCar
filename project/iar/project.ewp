# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK60D10/drivers; ..; ../../../../../../devices/MK60D10/utilities; ../../../..; ../../../../../../devices/MK60D10; ..\..\drivers; ..\..\eMPL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK60D10/drivers; ..; ../../../../../../devices/MK60D10/utilities; ../../../..; ../../../../../../devices/MK60D10
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  group board
    ../: board.c clock_config.c
  group car
    ../: CarSub.C CarSub.H
  group doc
    ./: MK60DN512xxx10_flash.icf
    debug/list/: project.map
    ../: readme.txt
    ../../documents/: 说明 .txt
  group drivers
    ../../../../../../devices/MK60D10/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dspi.c fsl_edma.c fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_wdog.c fsl_wdog.h
  group eMPL
    ../../eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group source
    ../: project.c test.c
  group startup
    ../../../../../../devices/MK60D10/iar/: startup_MK60D10.s
    ../../../../../../devices/MK60D10/: system_MK60D10.c system_MK60D10.h
  group user_drivers
    ../../drivers/: adc0.c adc1.c adc_pdb.c angle.c ccd0.c ccd1.c delay.c hc_sr04.c i2c.c i2c_ee.c imu.c imu.h Kalman_filter.c key.c led.c mpu6050.c nrf24l01.c oled.c ov7725.c pit.c pwm.c speed.c speed_quad.c usart.c
  group utilities
    ../../../../../../devices/MK60D10/utilities/: fsl_debug_console.c fsl_debug_console.h
